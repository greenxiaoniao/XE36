# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx, USE_STM32H743I_EVAL
  c misc: --C99
  c include: ../Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/BSP/STM32H743I-EVAL;../Drivers/BSP/Components/Common;../Utilities/Log;../Utilities/Fonts;../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/BSP/STM32H743I-EVAL
    ../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_io.c stm32h743i_eval.c stm32h743i_eval_bus.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_exti.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_i2c.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/User
    ../Src/: stm32h7xx_it.c main.c stm32h7xx_hal_msp.c Gpio.c uart.c adc.c i2c.c spi.c flash.c cpld.c lcd.c modbus.c common.c key.c Display_Function.c math.c ical_motor.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
